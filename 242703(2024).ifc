Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50356248-56fd-404e-bfe4-5503dd407272, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 242703(2024).ifc
Time: 2025-01-29T23:40:56
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 242703(2024):242703 Hand shower, d 110 mm, 242703(2024):242703 Hand shower, d 110 mm:351372
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 242703(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1112; ETIM Class Number: EC010161 Hand shower; LVI Number: 6510339; Noise Class: I (ISO 3822); NRF Number: 1365156; RSK Number: 8233073; UNSPSC Class Number: 30181803 Hand held shower unit; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/242703; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; VVS Number: 738629104
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa With Flow Reducers: 0.2 dm3/s; Hand Shower Size: Ø 110 mm; Max. Hot Water Supply: 65 C; Shower Parts: Anti limescale technology (easy to clean); Shower Spray: Pulsating - Strong water stream for massage or body treatment;Intense - invigorating water stream;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - NominalDepth: 78.1 mm; NominalHeight: 238.2 mm; NominalWidth: 109.6 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/242703; Catalog Drawing URL: http://static.oras.com/catdrw/242703; Category B2B: Accessories; Category B2C: Shower solutions; Color variants: 242703-33;242703-80;242703-81; Dimension Drawing URL: http://static.oras.com/dimdrw/242703; FDV Document URL: http://www.oras.com/datasheet/242703/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/242703; Group: Hand shower; Installation and Maintenance Guide URL: http://static.oras.com/manual/242703; Interactive AR View URL: https://static.oras.com/AR/242703; Long Marketing: Oras Aurelia A Symphony of Simplicity and Elegance. Discover the harmony of Oras Aurelia, a symphony of simplicity and elegance. AURELIA draws design inspiration from the exquisite elements of wild nature. From the graceful Lotus flower transformed into a spray face, designed for pure enjoyment, to the simplest curve of a tiny waterdrop shaping our hand shower, each detail reflects the beauty surrounding us in nature. Grace is key to every element, creating a seamless connection between form and function. 110mm – 3 spray face Handshower Easy push diverter for simple selection of spray face ELEVATING YOUR MOMENTS; Manufacturer: Oras; Market: Denmark;Estonia;International;Lithuania;Latvia;Norway;Poland;Sweden; Mobile Product Information URL: http://mpi.oras.com/242703; Model: 242703 Hand shower, d 110 mm; Name_en: 242703 Hand shower, d 110 mm; OmniClass Number: 23.45.55.00; Product Code: 242703; Product Family: Oras Aurelia; Product Image URL: http://static.oras.com/image/242703; Product URL: http://static.oras.com/242703; Technical DataSheet URL: http://www.oras.com/datasheet/242703/en; Type Name: 242703 Hand shower, d 110 mm; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 242703(2024); Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 242703; Name: 242703 Hand shower, d 110 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 242703; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 242703 Hand shower, d 110 mm
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 242703 Hand shower, d 110 mm; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0533023 m2; Volume: 0.00204094 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 242703(2024); Family and Type: 242703(2024): 242703 Hand shower, d 110 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 242703 Hand shower, d 110 mm; Type Id: 351350; WarrantyStartDate: n/a
